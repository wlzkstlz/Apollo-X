# Keil uVision project Apollo.uvprojx, settings and files
target Apollo (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Apollo
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,HAL_SDRAM_MODULE_ENABLED,HAL_LTDC_MODULE_ENABLED,HAL_DMA2D_MODULE_ENABLED,HAL_SRAM_MODULE_ENABLED
  c include: ../Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc;   ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;   ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;   ../Drivers/CMSIS/Include;   ..\Src\SDRAM;   ..\Src\delay;   ..\Src\LCD;   ..\Src\STMFLASH;   ..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/User
    ../Src/: main.c gpio.c stm32f4xx_hal_msp.c stm32f4xx_it.c usart.c can.c Communication.c PathData.c AutoPilot.c CommonAlg.c PathFollower.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_uart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_sdram.c stm32f4xx_ll_fmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sram.c
  group SDRAM
    ../Src/SDRAM/: sdram.c
  group LCD
    ../Src/LCD/: lcd.c ltdc.c lcd_show.c
  group delay
    ../Src/delay/: delay.c
  group STMFLASH
    ../Src/STMFLASH/: stmflash.c
software components: CMSIS:CORE 4.1.0
